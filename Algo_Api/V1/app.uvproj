# Keil uVision project app.uvproj, settings and files
target M3_app (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: app +hex
  AfterMake: fromelf --bin -o ..\..\bin\M3_app.bin .\output\app.axf
  c flags: OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\boot;.\include;..\..\lib\CMSIS\Core;..\..\lib\STM32F10x_StdPeriph_Driver\inc;..\..\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --first inituser.o(Start)
  group boot
    ../../lib/CMSIS/Core/: core_cm3.c
    ./boot/: AppBoot.lib
  group app
    ./api/: main.c DS18B20.c System_var.c M3_wifi.c Infrared.c M3_315.c debug_led.c Timer.c spi.c DK_RFM69H.c nrf24l01.c
  group lib
    ../../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c
